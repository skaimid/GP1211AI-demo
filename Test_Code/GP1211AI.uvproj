# Keil uVision project GP1211AI.uvproj, settings and files
target STC8A8K (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: GP1211AI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Src
    ./: GP1211AI.c
